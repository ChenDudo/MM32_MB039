# IAR project eth.ewp, settings and files
configuration MB039 (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __IAR; __MM3U1; __MM32_MB039; __MDM2803_N; __FM24C02; __WIDESCREEN; CLOCK=8000000
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\bsp\inc; ..\..\driver\inc; ..\..\app\eth\inc; ..\..\lib\HAL_lib\inc; ..\..\lib\startup\inc; ..\..\lwip\src; ..\..\lwip\src\include; ..\..\lwip\src\include\compat; ..\..\lwip\src\include\netif; ..\..\lwip\src\include\lwip; ..\..\lwip\src\include\lwip\apps; ..\..\lwip\src\include\lwip\priv; ..\..\lwip\src\include\lwip\prot; ..\..\app\eth\arch; ..\..\app\eth
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.ADefines: MM3U1
  OBJCOPY.OOCOutputFile: eth.srec
  ILINK.IlinkOutputFile: uid.out
  ILINK.IlinkIcfFile: eth.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../app/eth/: adc.c datetime.c hci.c lcd.c main.c music.c rtc.c
  group app/com
    ../../app/eth/: can.c i2c.c sdio.c spi.c spiflash.c uart.c
  group app/eth
    ../../app/eth/: dhcp_client.c eth.c http_server.c tcp_server.c
  group bsp
    ../../bsp/: bsp.c bsp_adc.c bsp_beep.c bsp_can.c bsp_comp.c bsp_crs.c bsp_dac.c bsp_eth.c bsp_fatFS.c bsp_i2c.c bsp_key.c bsp_lcd.c bsp_led.c bsp_mco.c bsp_opamp.c bsp_phy8720.c bsp_sdio.c bsp_spi.c bsp_tim.c bsp_uart.c
  group FatFs
    ../../thirdParty/FATFS/: diskio.c ff.c ffsystem.c ffunicode.c
  group lib
    ../../lib/HAL_lib/: common.c HAL_adc.c HAL_aes.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_crc.c HAL_crs.c HAL_dac.c HAL_dbg.c HAL_div.c HAL_dma.c hal_eth.c HAL_exti.c HAL_flash.c hal_fsmc.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_nvic.c HAL_opamp.c HAL_pwr.c HAL_rcc.c HAL_rtc.c hal_sdio.c HAL_spi.c HAL_sqrt.c HAL_tim.c HAL_uart.c HAL_uid.c HAL_wwdg.c
  group lwip
    ../../app/eth/arch/: ethernetif.c
  group lwip/api
    ../../lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/core
    ../../lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/core/ipv4
    ../../lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/http
    ../../lwip/src/apps/http/: fs.c httpd.c
  group lwip/netif
    ../../lwip/src/netif/: ethernet.c
  group system
    ../../lib/startup/: mm32_startup.c mm32_system.c
